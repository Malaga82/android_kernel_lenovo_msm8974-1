## drivers/platform/lenovo/Kconfig
```kconfig
# Lenovo configuration options

config MACH_LENOVO_K920
	bool "k920 board"
	help
		Support for Lenovo K920
```
